# Copyright (C) 2019-2020 NXP
require optee-os.imx.inc

OPTEE_OS_SRC = "git://github.com/nxp-imx/imx-optee-os.git;protocol=https"
SRCBRANCH = "imx_5.4.3_2.0.0"
SRCREV = "b32a9b6b9fa474359464ca70e62b796a45e16e36"
