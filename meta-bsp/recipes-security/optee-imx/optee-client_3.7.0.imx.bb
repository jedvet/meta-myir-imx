# Copyright (C) 2019-2020 NXP
require optee-client.imx.inc

OPTEE_CLIENT_SRC = "git://github.com/nxp-imx/imx-optee-client.git;protocol=https"
SRCBRANCH = "imx_5.4.3_2.0.0"
SRCREV = "bc0ec8ce1e4dc5ae23f4737ef659338b7cd408fe" 

